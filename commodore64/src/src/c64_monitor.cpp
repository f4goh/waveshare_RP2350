/*
 * c64_monitor.c - Moniteur integre C64 6510/1541 pour Waveshare RP2350-PiZero
 * Accessible via F3 a l'ecran et sur la console UART0 (GPIO 14/15 115200 baud).
 */

#include "c64_monitor.h"
#include "board_config.h"
#include "hardware/uart.h"
#include "pico/stdlib.h"
#include <stdio.h>
#include <string.h>
#include <ctype.h>

extern "C" {
uint8_t *c64_get_ram(void);
void c64_reset(void);
void c64_nmi(void);
}

// VIC Framebuffer
extern uint8_t g_pixels[384 * 272];

static bool s_monActive = false;
static char s_uartLineBuf[80];
static int  s_uartLineIdx = 0;

#define MON_LINES 24
#define MON_COLS  40
static char s_screenText[MON_LINES][MON_COLS + 1];
static int  s_curLine = 0;

static void mon_cls(void)
{
    for (int y = 0; y < MON_LINES; y++) {
        memset(s_screenText[y], ' ', MON_COLS);
        s_screenText[y][MON_COLS] = '\0';
    }
    s_curLine = 0;
}

static void mon_print(const char *str)
{
    while (*str) {
        if (*str == '\n') {
            s_curLine++;
            if (s_curLine >= MON_LINES) {
                for (int y = 1; y < MON_LINES; y++) {
                    memcpy(s_screenText[y - 1], s_screenText[y], MON_COLS + 1);
                }
                memset(s_screenText[MON_LINES - 1], ' ', MON_COLS);
                s_screenText[MON_LINES - 1][MON_COLS] = '\0';
                s_curLine = MON_LINES - 1;
            }
        } else if (*str >= 32 && *str < 127) {
            int len = strlen(s_screenText[s_curLine]);
            if (len < MON_COLS) {
                s_screenText[s_curLine][len] = *str;
                s_screenText[s_curLine][len + 1] = '\0';
            }
        }
        str++;
    }
}

static void mon_printf(const char *fmt, ...)
{
    char buf[128];
    va_list args;
    va_start(args, fmt);
    vsnprintf(buf, sizeof(buf), fmt, args);
    va_end(args);
    mon_print(buf);
    uart_puts(C64_UART_ID, buf);
}

void c64_monitor_init(void)
{
    uart_init(C64_UART_ID, C64_UART_BAUD);
    gpio_set_function(PIN_UART_TX, GPIO_FUNC_UART);
    gpio_set_function(PIN_UART_RX, GPIO_FUNC_UART);
    mon_cls();
    s_monActive = false;
    s_uartLineIdx = 0;
}

void c64_monitor_open(void)
{
    s_monActive = true;
    mon_cls();
    mon_printf("=== C64 MONITOR (RP2350) ===\n");
    mon_printf("COMMANDS: M <hex> (dump) | R (regs)\n");
    mon_printf("          W <addr> <val> | X (exit)\n");
    mon_printf("> ");
}

void c64_monitor_close(void)
{
    s_monActive = false;
}

bool c64_monitor_is_open(void)
{
    return s_monActive;
}

static void exec_command(char *cmd)
{
    while (*cmd == ' ') cmd++;
    if (*cmd == '\0') {
        mon_printf("> ");
        return;
    }

    char op = toupper((unsigned char)*cmd++);
    while (*cmd == ' ') cmd++;

    uint8_t *ram = c64_get_ram();

    if (op == 'X' || op == 'Q') {
        c64_monitor_close();
        return;
    } else if (op == 'M') {
        unsigned int addr = 0x0801;
        sscanf(cmd, "%x", &addr);
        addr &= 0xFFFF;
        if (ram) {
            for (int row = 0; row < 8; row++) {
                uint16_t a = (addr + row * 8) & 0xFFFF;
                mon_printf("%04X: ", a);
                for (int b = 0; b < 8; b++) {
                    mon_printf("%02X ", ram[(a + b) & 0xFFFF]);
                }
                mon_printf("| ");
                for (int b = 0; b < 8; b++) {
                    uint8_t ch = ram[(a + b) & 0xFFFF];
                    mon_printf("%c", (ch >= 32 && ch < 127) ? ch : '.');
                }
                mon_printf("\n");
            }
        }
    } else if (op == 'W') {
        unsigned int addr = 0, val = 0;
        if (sscanf(cmd, "%x %x", &addr, &val) == 2 && ram) {
            ram[addr & 0xFFFF] = (uint8_t)val;
            mon_printf("Wrote %02X to %04X\n", val & 0xFF, addr & 0xFFFF);
        } else {
            mon_printf("Syntax: W <addr> <val>\n");
        }
    } else if (op == 'R') {
        mon_printf("C64 RAM at %p\n", ram);
    } else {
        mon_printf("Unknown command. M, W, R, X\n");
    }
    mon_printf("> ");
}

void c64_monitor_uart_poll(void)
{
    while (uart_is_readable(C64_UART_ID)) {
        char c = (char)uart_getc(C64_UART_ID);
        if (c == '\r' || c == '\n') {
            uart_putc(C64_UART_ID, '\r');
            uart_putc(C64_UART_ID, '\n');
            s_uartLineBuf[s_uartLineIdx] = '\0';
            exec_command(s_uartLineBuf);
            s_uartLineIdx = 0;
        } else if (c == 0x08 || c == 0x7F) {
            if (s_uartLineIdx > 0) {
                s_uartLineIdx--;
                uart_puts(C64_UART_ID, "\b \b");
            }
        } else if (s_uartLineIdx < (int)sizeof(s_uartLineBuf) - 1 && c >= 32 && c < 127) {
            s_uartLineBuf[s_uartLineIdx++] = c;
            uart_putc(C64_UART_ID, c);
        }
    }
}

// Compact 6x8 bitmap font from startscreen/disk_ui
extern const uint8_t font_6x8[][8] = {
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 32 Space
    {0x20,0x20,0x20,0x20,0x20,0x00,0x20,0x00}, // 33 !
    {0x50,0x50,0x50,0x00,0x00,0x00,0x00,0x00}, // 34 "
    {0x50,0x50,0xF8,0x50,0xF8,0x50,0x50,0x00}, // 35 #
    {0x20,0x78,0xA0,0x70,0x28,0xF0,0x20,0x00}, // 36 $
    {0xC0,0xC8,0x10,0x20,0x40,0x98,0x18,0x00}, // 37 %
    {0x40,0xA0,0xA0,0x40,0xA8,0x90,0x68,0x00}, // 38 &
    {0x20,0x20,0x40,0x00,0x00,0x00,0x00,0x00}, // 39 '
    {0x10,0x20,0x40,0x40,0x40,0x20,0x10,0x00}, // 40 (
    {0x40,0x20,0x10,0x10,0x10,0x20,0x40,0x00}, // 41 )
    {0x00,0x20,0xA8,0x70,0xA8,0x20,0x00,0x00}, // 42 *
    {0x00,0x20,0x20,0xF8,0x20,0x20,0x00,0x00}, // 43 +
    {0x00,0x00,0x00,0x00,0x00,0x20,0x20,0x40}, // 44 ,
    {0x00,0x00,0x00,0xF8,0x00,0x00,0x00,0x00}, // 45 -
    {0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x00}, // 46 .
    {0x00,0x08,0x10,0x20,0x40,0x80,0x00,0x00}, // 47 /
    {0x70,0x88,0x98,0xA8,0xC8,0x88,0x70,0x00}, // 48 0
    {0x20,0x60,0x20,0x20,0x20,0x20,0x70,0x00}, // 49 1
    {0x70,0x88,0x08,0x30,0x40,0x80,0xF8,0x00}, // 50 2
    {0x70,0x88,0x08,0x30,0x08,0x88,0x70,0x00}, // 51 3
    {0x10,0x30,0x50,0x90,0xF8,0x10,0x10,0x00}, // 52 4
    {0xF8,0x80,0xF0,0x08,0x08,0x88,0x70,0x00}, // 53 5
    {0x30,0x40,0x80,0xF0,0x88,0x88,0x70,0x00}, // 54 6
    {0xF8,0x08,0x10,0x20,0x40,0x40,0x40,0x00}, // 55 7
    {0x70,0x88,0x88,0x70,0x88,0x88,0x70,0x00}, // 56 8
    {0x70,0x88,0x88,0x78,0x08,0x10,0x60,0x00}, // 57 9
    {0x00,0x00,0x20,0x00,0x00,0x20,0x00,0x00}, // 58 :
    {0x00,0x00,0x20,0x00,0x00,0x20,0x20,0x40}, // 59 ;
    {0x08,0x10,0x20,0x40,0x20,0x10,0x08,0x00}, // 60 <
    {0x00,0x00,0xF8,0x00,0xF8,0x00,0x00,0x00}, // 61 =
    {0x40,0x20,0x10,0x08,0x10,0x20,0x40,0x00}, // 62 >
    {0x70,0x88,0x10,0x20,0x20,0x00,0x20,0x00}, // 63 ?
    {0x70,0x88,0xB8,0xA8,0xB8,0x80,0x70,0x00}, // 64 @
    {0x70,0x88,0x88,0xF8,0x88,0x88,0x88,0x00}, // 65 A
    {0xF0,0x88,0x88,0xF0,0x88,0x88,0xF0,0x00}, // 66 B
    {0x70,0x88,0x80,0x80,0x80,0x88,0x70,0x00}, // 67 C
    {0xE0,0x90,0x88,0x88,0x88,0x90,0xE0,0x00}, // 68 D
    {0xF8,0x80,0x80,0xF0,0x80,0x80,0xF8,0x00}, // 69 E
    {0xF8,0x80,0x80,0xF0,0x80,0x80,0x80,0x00}, // 70 F
    {0x70,0x88,0x80,0xB8,0x88,0x88,0x70,0x00}, // 71 G
    {0x88,0x88,0x88,0xF8,0x88,0x88,0x88,0x00}, // 72 H
    {0x70,0x20,0x20,0x20,0x20,0x20,0x70,0x00}, // 73 I
    {0x38,0x10,0x10,0x10,0x90,0x90,0x60,0x00}, // 74 J
    {0x88,0x90,0xA0,0xC0,0xA0,0x90,0x88,0x00}, // 75 K
    {0x80,0x80,0x80,0x80,0x80,0x80,0xF8,0x00}, // 76 L
    {0x88,0xD8,0xA8,0xA8,0x88,0x88,0x88,0x00}, // 77 M
    {0x88,0xC8,0xA8,0x98,0x88,0x88,0x88,0x00}, // 78 N
    {0x70,0x88,0x88,0x88,0x88,0x88,0x70,0x00}, // 79 O
    {0xF0,0x88,0x88,0xF0,0x80,0x80,0x80,0x00}, // 80 P
    {0x70,0x88,0x88,0x88,0xA8,0x90,0x68,0x00}, // 81 Q
    {0xF0,0x88,0x88,0xF0,0xA0,0x90,0x88,0x00}, // 82 R
    {0x70,0x88,0x80,0x70,0x08,0x88,0x70,0x00}, // 83 S
    {0xF8,0x20,0x20,0x20,0x20,0x20,0x20,0x00}, // 84 T
    {0x88,0x88,0x88,0x88,0x88,0x88,0x70,0x00}, // 85 U
    {0x88,0x88,0x88,0x88,0x50,0x50,0x20,0x00}, // 86 V
    {0x88,0x88,0x88,0xA8,0xA8,0xD8,0x88,0x00}, // 87 W
    {0x88,0x88,0x50,0x20,0x50,0x88,0x88,0x00}, // 88 X
    {0x88,0x88,0x50,0x20,0x20,0x20,0x20,0x00}, // 89 Y
    {0xF8,0x08,0x10,0x20,0x40,0x80,0xF8,0x00}, // 90 Z
    {0x70,0x40,0x40,0x40,0x40,0x40,0x70,0x00}, // 91 [
    {0x00,0x80,0x40,0x20,0x10,0x08,0x00,0x00}, // 92 backslash
    {0x70,0x10,0x10,0x10,0x10,0x10,0x70,0x00}, // 93 ]
    {0x20,0x50,0x88,0x00,0x00,0x00,0x00,0x00}, // 94 ^
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xF8}, // 95 _
    {0x40,0x20,0x10,0x00,0x00,0x00,0x00,0x00}, // 96 `
    {0x00,0x00,0x70,0x08,0x78,0x88,0x78,0x00}, // 97 a
    {0x80,0x80,0xB0,0xC8,0x88,0xC8,0xB0,0x00}, // 98 b
    {0x00,0x00,0x70,0x80,0x80,0x88,0x70,0x00}, // 99 c
    {0x08,0x08,0x68,0x98,0x88,0x98,0x68,0x00}, // 100 d
    {0x00,0x00,0x70,0x88,0xF8,0x80,0x70,0x00}, // 101 e
    {0x30,0x48,0x40,0xE0,0x40,0x40,0x40,0x00}, // 102 f
    {0x00,0x00,0x68,0x98,0x98,0x68,0x08,0x70}, // 103 g
    {0x80,0x80,0xB0,0xC8,0x88,0x88,0x88,0x00}, // 104 h
    {0x20,0x00,0x60,0x20,0x20,0x20,0x70,0x00}, // 105 i
    {0x10,0x00,0x30,0x10,0x10,0x90,0x60,0x00}, // 106 j
    {0x80,0x80,0x90,0xA0,0xC0,0xA0,0x90,0x00}, // 107 k
    {0x60,0x20,0x20,0x20,0x20,0x20,0x70,0x00}, // 108 l
    {0x00,0x00,0xD0,0xA8,0xA8,0xA8,0xA8,0x00}, // 109 m
    {0x00,0x00,0xB0,0xC8,0x88,0x88,0x88,0x00}, // 110 n
    {0x00,0x00,0x70,0x88,0x88,0x88,0x70,0x00}, // 111 o
    {0x00,0x00,0xB0,0xC8,0xC8,0xB0,0x80,0x80}, // 112 p
    {0x00,0x00,0x68,0x98,0x98,0x68,0x08,0x08}, // 113 q
    {0x00,0x00,0xB0,0xC8,0x80,0x80,0x80,0x00}, // 114 r
    {0x00,0x00,0x78,0x80,0x70,0x08,0xF0,0x00}, // 115 s
    {0x40,0x40,0xE0,0x40,0x40,0x48,0x30,0x00}, // 116 t
    {0x00,0x00,0x88,0x88,0x88,0x98,0x68,0x00}, // 117 u
    {0x00,0x00,0x88,0x88,0x88,0x50,0x20,0x00}, // 118 v
    {0x00,0x00,0x88,0xA8,0xA8,0xA8,0x50,0x00}, // 119 w
    {0x00,0x00,0x88,0x50,0x20,0x50,0x88,0x00}, // 120 x
    {0x00,0x00,0x88,0x88,0x98,0x68,0x08,0x70}, // 121 y
    {0x00,0x00,0xF8,0x10,0x20,0x40,0xF8,0x00}, // 122 z
    {0x10,0x20,0x20,0x40,0x20,0x20,0x10,0x00}, // 123 {
    {0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x00}, // 124 |
    {0x40,0x20,0x20,0x10,0x20,0x20,0x40,0x00}, // 125 }
    {0x00,0x00,0x40,0xA8,0x10,0x00,0x00,0x00}, // 126 ~
};

void c64_monitor_render(void)
{
    if (!s_monActive) return;

    // Fond bleu fonce (palette index 254 = 0x352879) et texte blanc (index 1)
    uint8_t *fb = g_pixels;
    for (int y = 0; y < 240; y++) {
        uint8_t *row = fb + (y + C64_CROP_TOP) * C64_DISPLAY_WIDTH + C64_CROP_LEFT;
        memset(row, 254, 320);
    }

    for (int y = 0; y < MON_LINES; y++) {
        int py = y * 10 + 2;
        for (int x = 0; x < MON_COLS; x++) {
            char ch = s_screenText[y][x];
            if (ch <= 32 || ch > 126) continue;
            const uint8_t *glyph = font_6x8[(unsigned char)ch - 32];
            int px = x * 8 + 4;
            for (int r = 0; r < 8; r++) {
                uint8_t bits = glyph[r];
                uint8_t *dst = fb + (py + r + C64_CROP_TOP) * C64_DISPLAY_WIDTH + px + C64_CROP_LEFT;
                for (int c = 0; c < 6; c++) {
                    if (bits & (0x80 >> c)) {
                        dst[c] = 1; // Blanc
                    }
                }
            }
        }
    }
}

void c64_monitor_key(uint8_t ascii)
{
    if (!s_monActive) return;
    if (ascii == 0x1B) { // ESC
        c64_monitor_close();
    } else if (ascii == '\r' || ascii == '\n') {
        s_uartLineBuf[s_uartLineIdx] = '\0';
        mon_printf("\n");
        exec_command(s_uartLineBuf);
        s_uartLineIdx = 0;
    } else if (ascii == 0x08 || ascii == 0x7F) {
        if (s_uartLineIdx > 0) {
            s_uartLineIdx--;
            int len = strlen(s_screenText[s_curLine]);
            if (len > 0) s_screenText[s_curLine][len - 1] = '\0';
        }
    } else if (s_uartLineIdx < (int)sizeof(s_uartLineBuf) - 1 && ascii >= 32 && ascii < 127) {
        s_uartLineBuf[s_uartLineIdx++] = (char)ascii;
        char temp[2] = { (char)ascii, '\0' };
        mon_print(temp);
    }
}
